# Keil uVision project BounceCar.uvproj, settings and files
target BounceCar (ARM-ADS)
  device: Mini58FDE Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: BounceCar
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3
  c define: MINI58
  c include: ..\Library\CMSIS\Include;..\Library\StdDriver\inc;.\XN297L\inc;..\Keil;..\Library\Device\Nuvoton\Mini58Series\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_Mini58Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../Library/Device/Nuvoton/Mini58Series/Source/: system_Mini58Series.c
    ../Library/Device/Nuvoton/Mini58Series/Source/ARM/: startup_Mini58Series.s
  group Library
    ../Library/StdDriver/src/: sys.c uart.c retarget.c adc.c clk.c fmc.c gpio.c i2c.c pwm.c spi.c timer.c
  group User
    ./: main.c LED.c Timer_Ctrl.c Motor.c Battery.c UartCtrl.c FlashCtrl.c RC.c FailSafe.c PID.c Control.c ConfigTable.c NVT_I2C.c filter.c IMUSO3.c IMU.c MPU6050.c I2Cdev.c DMP.c Comm.c Report.c SleepCtrl.c Audio.c jump.c
    ./XN297L/src/: RF.c
  group Include
    ./: def.h led.h Timer_Ctrl.h Motor.h Battery.h UartCtrl.h FlashCtrl.h RC.h FailSafe.h PID.h Control.h ConfigTable.h MPU6050.h NVT_I2C.h I2CDev.h filter.h IMU.h IMUSO3.h DMP.h Comm.h Report.h SleepCtrl.h
    ./XN297L/inc/: RF.H
